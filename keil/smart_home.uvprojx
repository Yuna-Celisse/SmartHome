# Keil uVision project smart_home.uvprojx, settings and files
target smart_home (6220000::V6.22::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: smart_home +hex
  BeforeMake: cmd.exe /C "..\mspm0-sdk\tools\keil\syscfg.bat '$P' smart_home.syscfg"
  AfterMake: .\keil-build-viewer.exe
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ../app;../app/sensors;../;..\mspm0-sdk\source\third_party\CMSIS\Core\Include;..\mspm0-sdk\source
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: ./mspm0g3507.sct
  link misc: ..\mspm0-sdk\source\ti\driverlib\lib\keil\m0p\mspm0g1x0x_g3x0x\driverlib.a
  group Source
    ../app/: main.c board_init.c board_init.h voice_protocol.c voice_protocol.h
    ../: smart_home.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_mspm0g350x_uvision.s
    ../app/sensors/: sensor_hdc2010.c sensor_hdc2010.h sensor_tmp007.c sensor_tmp007.h sensor_bmi160.c sensor_bmi160.h sensor_bme280.c sensor_bme280.h sensor_opt3001.c sensor_opt3001.h sensor_drv5055.c sensor_drv5055.h
